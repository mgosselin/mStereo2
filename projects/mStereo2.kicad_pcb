# Repository mgosselin/mStereo2

File README.md:

# mStereo: revision 2

mStereo is a two-channel digital-to-analog converter (DAC) for audio. It is under active development.

## In this repository
    .
    ├── doc             # documents and media used in the README documentation
    ├── libraries       # kicad library files
    └── projects        # kicad project files
        ├── gerbers     # gerber files for PCB fabrication 
        └── bom         # bill of materials and supplementary information

## Using the contents of this repository

This repo is built and maintained with Linux users in mind.  Some contents are .pdf or plain text so the repo may be cloned and those files may be opened irrespective of the platform.  Users wishing to use the Kicad project and other Kicad files by cloning and/or forking the repo can do so in Linux: no support is implied for OSX or windows users (although generally, OSX users should experience no problems).  
    
## Scope

mStereo is intended to be used as a component in systems for playback of high-resolution digital audio stored on computers.

## Electrical Specifications

| Specification                                                      | Value     | Unit     |
| -------------                                                      |:---:      | -----    |
| +12 V supply current draw **                                       | 70        | mA       |
| -12 V supply current draw **                                       | 69        | mA       |
| +5 V supply current draw **                                        | 259       | mA       |
| Output impedance ***                                               | 20.3      | Ώ        |
| Output DC voltage offset ***                                       | ± 1       | mV       |
| Output RMS voltage level at 0 dBFS ***                             | 4.000     | V        |

**  _measured with each channel driving 100 Ώ resistive load_

*** _measured across + and - output terminals_

## Schematic

## Circuit Description

## Circuit Board

[Gerber files here](https://github.com/mgosselin/mStereo2/blob/master/projects/gerbers/).

## [BOM Page](https://github.com/mgosselin/mStereo2/blob/master/projects/bom)

## Assembly

## Ordering

At present, mStereo2 circuit boards (not populated) are available.  They may be obtained at-cost from me, by direct request.  

## History

mStereo is currently on revision 2.  Revision 1 is superceeded by revision 2, and while conceptually similar the hardware have little overlap.  Thus revision 1 documenation will no longer be updated and will remain accessible only by request.  

Since computers have become by far the most common way to exchange, store and playback audio recordings, the task remains to develop hardware to accompany computers and provide the best possible user experience. Since I am very serious about high-fidelity reproduction of audio recordings, developing my own hardware is challenging and rewarding on many fronts.

Practically, this means seeking the best possible hardware components (DAC ICs, oscillators, power supplies, etc.), integrating them, and ensuring their implementation permits their maximum specifications to be realized.

## KiCad design projects/mStereo2.kicad_pcb

Parts:
C101, C102, C103, C104, C105, C106, C107: 0.1
D101: AMBER_LED
D102, D104, D105: GREEN_LED
D103: RED_LED
P101: CONN_AMANERO
P102: Screw-term 1x2
P103: Screw-term 1X3
P104, P105: XLR-MALE
R101, R102, R103: 121
R104, R105: 825
U101: ISO7640
U102: CDCLVC1104
U103: MCP100-315DI
U104: SRC4192
X101: XTAL

Connections:
+5V: P102.1; also elsewhere on the board
+12V: P103.1, R104.1; also elsewhere on the board
-12V: P103.3, R105.2; also elsewhere on the board
/BCLK_1: P101.4, U101.4 (IN_B)
/BCLK_2: U101.13 (OUT_B), U104.5 (BCKI)
/DAC_L/BCLK: U104.25 (BCKO); also elsewhere on the board
/DAC_L/DATA: U104.23 (SDOUT); also elsewhere on the board
/DAC_L/LRCLK: U104.24 (LRCKO); also elsewhere on the board
/DAC_L/MCLK: U102.8 (Y1); also elsewhere on the board
/DAC_R/MCLK: U102.7 (Y3); also elsewhere on the board
/DATA_1: P101.3, U101.5 (IN_C)
/DATA_2: U101.12 (OUT_C), U104.4 (SDIN)
/FILTER_L/VOUT+: P104.2; also elsewhere on the board
/FILTER_L/VOUT-: P104.3; also elsewhere on the board
/FILTER_R/VOUT+: P105.2; also elsewhere on the board
/FILTER_R/VOUT-: P105.3; also elsewhere on the board
/LRCLK_1: P101.5, U101.3 (IN_A)
/LRCLK_2: U101.14 (OUT_A), U104.6 (LRCKI)
/SRC_MCLK: U102.5 (Y2), U104.2 (RCKI)
/~RST: U103.1 (~RST), U104.13 (~RST)
DGND: C102.2, C103.2, C104.2, C105.2, C106.2, C107.2, D104.2 (K), D105.1 (A), P102.2, P103.2, P104.1, P105.1, R103.2, U101.9 (GND2), U101.15 (GND2), U102.4 (GND), U103.3 (GND), U104.1 (LGRP), U104.8 (DGND), U104.9 (BYPAS), U104.11 (IFMT1), U104.12 (IFMT2), U104.16 (OWL1), U104.17 (OWL0), U104.18 (OFMT1), U104.20 (TDMI), U104.21 (DGND), U104.28 (MODE2), X101.2 (GND); also elsewhere on the board
GNDA: C101.2, P101.8, R101.2, R102.2, U101.2 (GND1), U101.8 (GND1)
unnamed: D101.1 (A), P101.1
unnamed: D101.2 (K), R101.1
unnamed: D102.2 (K), R102.1
unnamed: D103.1 (A), U104.14 (MUTE), U104.15 (~RDY)
unnamed: D103.2 (K), R103.1
unnamed: D104.1 (A), R104.2
unnamed: D105.2 (K), R105.1
unnamed: U102.1 (CLKIN), X101.3 (OUT)
VAA: C101.1, D102.1 (A), P101.9, U101.1 (VCC1)
VCC: C102.1, C104.1, U102.6 (VDD), X101.1 (EN), X101.4 (VDD); also elsewhere on the board
VDD: C103.1, C105.1, C106.1, C107.1, U101.10 (EN), U101.16 (VCC2), U103.2 (VCC), U104.7 (VIO), U104.10 (IFMT0), U104.19 (OFMT0), U104.22 (VDD), U104.26 (MODE0), U104.27 (MODE1); also elsewhere on the board

Notes on the sheet:
Board perimeter must fit 1445T2201 (160mm W x 220mm L)
Board perimiter must fit 1U x 8in. deep rack case (400mm W x 200mm L)
Internal layers for GND and VCC. Top and Bottom for signals. This allows solid planes (VCC and GND) under components.
Meaured mating length for Sullins connectors = 13.11 mm Rec. Amanero standoff = 12.0 mm (0.472 in) [24434K-ND] Alt. Amanero standoff = 12.7 mm (0.500 in) [2203K-ND] Rec. male connector for Amanero: [S9172-ND] Alt. male connector for Amanero: [952-2130-ND] Mating XLR connector: [NC3FXX-B] Alternate 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
Required board top clearance = 23.83 mm Board-to-board mating height for Amanero connectors = 11.6 mm Gap from board edge to rear panel = 1 mm Dist. from XLR ctr. pt. to board edge = 10 mm
Board perimiter actual = 159.5mm x 120mm

Parts:
C201: 1
C202: 0.01
C203: 22
D201: GREEN_LED
R201: 121
U201: LT1761

Connections:
+5V: C201.1, U201.1 (VIN), U201.3 (~SHDN); also elsewhere on the board
DGND: C201.2, C203.2, R201.2, U201.2 (GND); also elsewhere on the board
unnamed: C202.2, U201.4 (BYP)
unnamed: D201.2 (K), R201.1
VCC: C202.1, C203.1, D201.1 (A), U201.5 (VOUT); also elsewhere on the board

Parts:
C301, C303, C305, C307, C309, C311: 0.1
C302, C304, C306, C308, C310, C312: 22
D301: RED_LED
R301: 121
U301: WM8741

Connections:
+5V: C303.1, C304.1, C307.1, C308.1, C311.1, C312.1, U301.9, U301.15, U301.20; also elsewhere on the board
/DAC_L/BCLK: U301.3; also elsewhere on the board
/DAC_L/DATA: U301.2; also elsewhere on the board
/DAC_L/LRCLK: U301.1; also elsewhere on the board
/DAC_R/MCLK: U301.5; also elsewhere on the board
/FILTER_R/VIN+: U301.12, U301.16; also elsewhere on the board
/FILTER_R/VIN-: U301.13, U301.17; also elsewhere on the board
DGND: C301.2, C302.2, C303.2, C304.2, C305.2, C306.2, C307.2, C308.2, C309.2, C310.2, C311.2, C312.2, R301.2, U301.4, U301.7, U301.10, U301.14, U301.19, U301.26, U301.27; also elsewhere on the board
unnamed: C305.1, C306.1, U301.11
unnamed: C309.1, C310.1, U301.18
unnamed: D301.1 (A), U301.21
unnamed: D301.2 (K), R301.1
VDD: C301.1, C302.1, U301.6, U301.8, U301.23, U301.24, U301.25, U301.28; also elsewhere on the board

Parts:
C401, C403, C405, C407, C409, C411: 0.1
C402, C404, C406, C408, C410, C412: 22
D401: RED_LED
R401: 121
U401: WM8741

Connections:
+5V: C403.1, C404.1, C407.1, C408.1, C411.1, C412.1, U401.9, U401.15, U401.20; also elsewhere on the board
/DAC_L/BCLK: U401.3; also elsewhere on the board
/DAC_L/DATA: U401.2; also elsewhere on the board
/DAC_L/LRCLK: U401.1; also elsewhere on the board
/DAC_L/MCLK: U401.5; also elsewhere on the board
/FILTER_L/VIN+: U401.13, U401.17; also elsewhere on the board
/FILTER_L/VIN-: U401.12, U401.16; also elsewhere on the board
DGND: C401.2, C402.2, C403.2, C404.2, C405.2, C406.2, C407.2, C408.2, C409.2, C410.2, C411.2, C412.2, R401.2, U401.4, U401.7, U401.10, U401.14, U401.19, U401.24, U401.26, U401.27; also elsewhere on the board
unnamed: C405.1, C406.1, U401.11
unnamed: C409.1, C410.1, U401.18
unnamed: D401.1 (A), U401.21
unnamed: D401.2 (K), R401.1
VDD: C401.1, C402.1, U401.6, U401.8, U401.23, U401.25, U401.28; also elsewhere on the board

Parts:
C501: 22
C502: 0.01
C503: 1
D501: GREEN_LED
R501: 121
U501: LT1763

Connections:
+5V: C503.1, U501.5 (~SHDN), U501.8 (VIN); also elsewhere on the board
DGND: C501.2, C503.2, R501.2, U501.3 (GND), U501.6 (GND), U501.7 (GND); also elsewhere on the board
unnamed: C502.2, U501.4 (BYP)
unnamed: D501.2 (K), R501.1
VDD: C501.1, C502.1, D501.1 (A), U501.1 (VOUT), U501.2 (SENSE); also elsewhere on the board

Parts:
C601, C602, C603, C604: 100
C605, C606: 0.1
C607, C608: 470p
R601, R602, R603, R604, R607, R608, R609, R610: 1.21k
R605, R606, R611, R612: 2.49k
R613, R614: 10
U601, U602: OPA1632

Connections:
+12V: C601.1, C603.1, C605.1, C606.1, U601.3 (V+), U602.3 (V+); also elsewhere on the board
-12V: C602.2, C604.2, C605.2, C606.2, U601.6 (V-), U602.6 (V-); also elsewhere on the board
/FILTER_L/VIN+: R601.1; also elsewhere on the board
/FILTER_L/VIN-: R602.1; also elsewhere on the board
/FILTER_L/VOUT+: R613.2; also elsewhere on the board
/FILTER_L/VOUT-: R614.2; also elsewhere on the board
DGND: C601.2, C602.1, C603.2, C604.1, U601.2 (VCOM), U602.2 (VCOM); also elsewhere on the board
unnamed: C607.1, R601.2, R603.1
unnamed: C607.2, R602.2, R604.1
unnamed: C608.1, R607.2, R609.1
unnamed: C608.2, R608.2, R610.1
unnamed: R603.2, R605.1, U601.8 (VIN+)
unnamed: R604.2, R606.1, U601.1 (VIN-)
unnamed: R605.2, R607.1, U601.5 (VOUT-)
unnamed: R606.2, R608.1, U601.4 (VOUT+)
unnamed: R609.2, R611.1, U602.8 (VIN+)
unnamed: R610.2, R612.1, U602.1 (VIN-)
unnamed: R611.2, R613.1, U602.5 (VOUT-)
unnamed: R612.2, R614.1, U602.4 (VOUT+)

Parts of its further copies:
C701, C702, C703, C704: 100
C705, C706: 0.1
C707, C708: 470p
R701, R702, R703, R704, R707, R708, R709, R710: 1.21k
R705, R706, R711, R712: 2.49k
R713, R714: 10
U701, U702: OPA1632

Connections of its further copies:
+12V: C701.1, C703.1, C705.1, C706.1, U701.3 (V+), U702.3 (V+); also elsewhere on the board
-12V: C702.2, C704.2, C705.2, C706.2, U701.6 (V-), U702.6 (V-); also elsewhere on the board
/FILTER_R/VIN+: R701.1; also elsewhere on the board
/FILTER_R/VIN-: R702.1; also elsewhere on the board
/FILTER_R/VOUT+: R713.2; also elsewhere on the board
/FILTER_R/VOUT-: R714.2; also elsewhere on the board
DGND: C701.2, C702.1, C703.2, C704.1, U701.2 (VCOM), U702.2 (VCOM); also elsewhere on the board
unnamed: C707.1, R701.2, R703.1
unnamed: C707.2, R702.2, R704.1
unnamed: C708.1, R707.2, R709.1
unnamed: C708.2, R708.2, R710.1
unnamed: R703.2, R705.1, U701.8 (VIN+)
unnamed: R704.2, R706.1, U701.1 (VIN-)
unnamed: R705.2, R707.1, U701.5 (VOUT-)
unnamed: R706.2, R708.1, U701.4 (VOUT+)
unnamed: R709.2, R711.1, U702.8 (VIN+)
unnamed: R710.2, R712.1, U702.1 (VIN-)
unnamed: R711.2, R713.1, U702.5 (VOUT-)
unnamed: R712.2, R714.1, U702.4 (VOUT+)

Notes on the sheet:
Gain = (1/2) x 2 x (1/2) x 2 = 1
Fc = 1 / [2 x pi x R x C]
Fc = 1 / [2 x pi x 1.21 x 10^3 x (2x470) x 10^-12] = 139 KHz

Board: 4 copper layers, 159.5 x 120.0 mm, 125 parts (1 on the bottom side), 73 nets.

Other parts of the board:
mounting_m3, mounting_m3#2, mounting_m3#3, mounting_m3#4, mounting_m3#5, mounting_m3#6, mounting_m3#7, mounting_m3#8: VAL**; mounting_m3

## KiCad design projects/mStereo2_02.kicad_pcb

Board: 2 copper layers, 67.0 x 105.0 mm, 7 parts (0 on the bottom side), 5 nets, no tracks yet.

Parts:
C1: 0.1; SM0805_topbotrefs
J1: CONN_AMANERO; 2x10_female
M101: MNT1; MOUNT_M3.5
M102: MNT2; MOUNT_M3.5
M103: MNT3; MOUNT_M3.5
M104: MNT4; MOUNT_M3.5
U1: ISO7240

Connections:
/GND1: C1.2, J1.8, U1.2
/VCC1: C1.1, J1.9, U1.1
unnamed: J1.2, U1.5
unnamed: J1.3, U1.4
unnamed: J1.4, U1.3

## Commit log

2014-10-28 Added intro paragraph
2014-10-29 added libraries and projects folders
2014-10-30 added image content for README
2014-11-01 added led_gosselin.lib; removed irrelevant *.lib files
2014-11-01 updated LED indicators in schematic files (*.sch)
2014-11-02 updated LEDs in schematic, output connectors, re-annotated
2014-11-02 updated power sheets
2014-11-03 updated cvpcb footprint/component links
2014-11-04 add pdf schematic
2014-11-09 add MSOP-8 SOIC-16 and TSSOP-28 footprints
2014-11-11 regorganize location of built-in libs and *.sch cleanup in /projects
2014-11-13 add more SMD IC footprints
2014-11-13 update lib-table
2014-11-26 update XLR connector part. Netlist now outdated.
2014-11-30 update netlist after changing to new XLR connectors
2014-11-30 add new footprints for discrete R, C, LED and update lib table
2014-11-30 update BOM
2014-11-30 update schematic notes
2014-12-06 updated notes with mating connector part numbers
2014-12-08 add box cap and small electrolytic cap footprints
2014-12-12 add connector footprints; change c_pol sch symbols
2014-12-12 cleanup /libraries of unused files
2014-12-17 Add key PCB and assembly dimensions in a table
2014-12-17 Split up dimensions table in wiki
2015-01-02 Add 'scope' to README, rearrange text.
2015-02-01 add equations into filter .sch sheets
2015-02-01 remove filter.sch and mStereo2.pro to avoid merge conflict
2015-02-01 add pdf of schematic sheet
2015-02-01 cleanup /projects directory
2015-02-01 add .png version of schematic
2015-02-01 change schematic image to ,jpg format
2015-02-01 Added schematic in .jpg format in-line
2015-02-01 remove old photos
2015-02-01 remove _autosave file
2015-02-01 Add BOM to README
2015-02-01 Fix refs in BOM table
2015-02-03 remove .cmp and .net: will replace later with updates
2015-02-03 re-add netlist, correct part numbers
2015-02-03 re-re-annotate to remove lowercase
2015-02-03 make new .cmp
2015-02-15 imported netlist to PcbNew, drew board outline and set origin
2015-02-16 prelimiary component positioning, board resizing, added mounting holes footprint
2015-02-20 remove open-project module
2015-02-22 secondary part positioning (DAC, filters)
2015-03-07 add mfg. spec. info; add dwg. info to sheet text feilds
2015-06-17 reposition parts, start routing, add notes for next rev. changes to /doc folder
2015-06-18 more routing: reached about 50% completion
2015-06-19 more routing; reached 75% completion
2015-06-21 more routing and component placement revision
2015-06-23 more routing and 3v3 power component placement
2015-06-27 place and route all LEDs; append to future additions list
2015-07-14 add dimensions, begin repositioning silkscreen reference numbers and component values
2015-07-18 rearrage silkscreen
2015-07-19 finalize silkscreen, ran DRC, did layer-by-layer visual sanity-check
2015-07-22 generate and check gerbers and excellon file
2015-07-24 final changes to top silkscreen layout
2015-07-31 fix errors reported by fab (hole spacing too close; 5 places), generate new set of gerbers for resubmission
2015-08-02 add layer stackup file for fabhouse reference
2015-08-08 BOM vendor spelling updates
2015-08-08 Add missing references R401, R301 to BOM
2015-08-08 update vendor name spelling and references in BOM
2015-08-08 update missing quantity for RNCP0805FTD121RCT-ND in BOM
2015-08-08 move BOM, add a README
2015-08-08 update document heir-achy table
2015-08-08 Move BOM documentation to a separate page
2015-08-08 add a .CSV copy of the BOM
2015-08-08 fix number of columns in row 9
2015-08-08 remove this in favor of a .csv copy
2015-08-08 Update link to .csv bom instead of bom readme
2015-08-08 add a markdown README for projects/bom page
2015-08-08 Type basic framework for BOM Notes
2015-08-10 BOM notes updates
2015-08-11 rename stackup file to avoid git documentation confusion
2015-08-11 add images of gerber files
2015-08-11 add images of kicad layout
2015-08-12 swap front mask image for a correct one
2015-08-12 fix repeated line entry in BOM
2015-08-12 Add PCB images
2015-08-12 Create easy-to-view README with gerber images
2015-08-12 split assembly information out into a separate doc
2015-08-12 Link to assembly page
2015-08-12 remove .BOM format of bill of materials
2015-08-12 make partial BOMs for each vendor for easy ordering
2015-08-13 Add tables for part information, links, formatting
2015-08-14 add drill file image
2015-08-14 Add photo of drill layer to README
2015-09-10 fix erroneous 1.21KOhm resistor digi-key-part-number (previously used a p/n for a 1kOhm resistor)
2015-09-28 updating the future_additions notes
2015-09-29 update future additions
2015-09-29 add LT1963A reg. to sch. notes
2015-10-01 update future_additions notes
2015-10-18 update BOM so most parts (all but one) are sourced from digi-key
2015-10-18 add specifications information
2015-10-18 further updates to specifications
2015-10-18 clean up assembly information tables
2015-10-21 correct error, format updates on specifications
2015-10-23 add chassis assembly info to BOM notes for now
2015-11-09 first commit of e24 BOM with correct P/Ns
2015-11-09 update e24 and s22 part numbers
2015-11-09 adding first drafts of power supplies and accessories BOMs
2015-11-09 update heatsink and connectors for 5V supply
2015-11-09 update trafo info
2015-11-09 final part number additions to e24 BOM
2015-11-09 finalize power supply boms, ready for ordering
2015-11-09 update part number of momentary swtich
2015-11-09 update rectifier part number: previous one was obsolete
2015-11-09 update connector, trafo, power entry part numbers in power supply BOMs
2015-11-09 reorganize AMB BOMs folder
2015-11-09 update s22 BOM
2015-11-09 remove broken link to assembly page
2015-11-09 adding AMB d1 BOM
2015-11-15 finalize d1 BOM
2015-11-16 add LCDuino-1 BOM and update future additions text file
2016-01-09 update trafo desc
2016-03-13 updates to AMB power supply BOMs
2016-03-13 fix leftover text left by mergetool
2016-03-13 remove stray errant quotation in e24.csv
2016-03-13 add fuse info to README
2016-03-14 updates to future_additions
2016-03-16 update s22 heatsink part number
2016-04-13 update future additions record
2016-04-16 fix duplicates in BOM
2016-07-04 update future additions notes

Notices in the files:
projects/mStereo2.kicad_pcb:
Public domain
Copyright (c) 2015 Michael I. Gosselin
